FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Supporting-Tion-Pro28.patch"
SRC_URI += "file://0002-Change-name-to-dtb-file.patch"
