SRCREV = "1919"
EXTRA_OECONF+= " --enable-cxx"
