FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-crypto-mxs-dcp-Initialize-.statesize-fields.patch \
            file://0002-Working-device-tree-for-Tion-Pro28.patch \
            file://defconfig \
"
